void intro()
{
    char s[255];
    int i, j;
    textcolor(7);
    clrscr();
    for (i = -10; i < 12; i++) {
        for (j = 0; j < (i + 1) / 2; j++) {
            gotoxy(1, j + 1);
            cprintf("                                                                        ");
        }
        if (i / 2 >= 0) {
            gotoxy(1, (i) / 2 + 1);
            if (i % 2 != 0) {
                if (i > 0)
                    gotoxy(1, (i) / 2 + 2);
                printf("        █   █ ▄▀▀▀▄ █▀▀▀▄ ▄▀▀▀▄   ▄▀█ █▀▀▀█ █▀▀▀▄ ▄▀▀▀▄ ▀▀█▀▀ █▀▀▀▄ ▄▀▀▀▄");
            } else
                printf("        ▄   ▄  ▄▄▄  ▄▄▄▄   ▄▄▄     ▄▄ ▄▄▄▄▄ ▄▄▄▄   ▄▄▄  ▄▄▄▄▄ ▄▄▄▄   ▄▄▄ ");
        }
        if (i / 2 >= -1) {
            gotoxy(1, (i) / 2 + 2);
            if (i % 2 != 0) {
                if (i > 0)
                    gotoxy(1, (i) / 2 + 3);
                printf("        █ ▄▀  █   █ █   █ █   █ ▄▀  █ █     █   █ █   ▀   █   █   █ █   █");
            } else
                printf("        █  ▄▀ █   █ █   █ █   █  ▄▀ █ █   ▀ █   █ █   █   █   █   █ █   █");
        }
        if (i / 2 >= -2) {
            gotoxy(1, i / 2 + 3);
            if (i % 2 != 0) {
                if (i > 0)
                    gotoxy(1, i / 2 + 4);
                printf("        █▀▄   █   █ █▄▄▄▀ █   █ █   █ █▀▀   █▀▀▀▄ █       █   █▀▀▀▄ █   █");
            } else
                printf("        █▄▀   █   █ █   █ █   █ █   █ █▄▄   █▄▄▄▀ █       █   █▄▄▄▀ █   █");
        }
        if (i / 2 >= -3) {
            gotoxy(1, i / 2 + 4);
            if (i % 2 != 0) {
                if (i > 0)
                    gotoxy(1, i / 2 + 5);
                printf("        █  █  █   █ █     █   █ █   █ █     █   █ █   ▄   █   █   █ █   █");
            } else
                printf("        █ ▀▄  █   █ █▀▀▀  █   █ █   █ █     █   █ █       █   █   █ █   █");
        }
        if (i / 2 >= -4) {
            gotoxy(1, i / 2 + 5);
            if (i % 2 != 0) {
                if (i > 0)
                    gotoxy(1, i / 2 + 6);
                printf("        █   █ ▀▄▄▄▀ █     ▀▄▄▄▀ █   █ █▄▄▄█ █▄▄▄▀ ▀▄▄▄▀   █   █▄▄▄▀ ▀▄▄▄▀");
            } else
                printf("        █  ▀▄ █   █ █     █   █ █   █ █   ▄ █   █ █   █   █   █   █ █   █");
        }
        if (i / 2 >= -5) {
            gotoxy(1, i / 2 + 6);
            if (i % 2 != 0) {
                if (i > 0)
                    gotoxy(1, i / 2 + 7);
                printf("                                                                         ");
            } else
                printf("        ▀   ▀  ▀▀▀  ▀      ▀▀▀  ▀   ▀ ▀▀▀▀▀ ▀▀▀▀   ▀▀▀    ▀   ▀▀▀▀   ▀▀▀ ");
        }
        delay(20);
    }
    for (i = 50; i > 24; i--) {
        if (i / 2 <= 25) {
            gotoxy(1, i / 2);
            if (i % 2 == 0)
                printf("                        ▄                                           ");
            else
                printf("                                                                    ");
        }
        if (i / 2 + 1 <= 25) {
            gotoxy(1, i / 2 + 1);
            if (i % 2 == 0)
                printf("              ▄▀▀▀▄  █     █ ▄▀▀█▀▀▄ ▄▀▀▀▀▀▄ █▀▀▀▀▀▄ █     █ ▄▀▀▀▀▀█");
            else
                printf("               ▄▄▄   ▄  ▀  ▄  ▄▄▄▄▄   ▄▄▄▄▄  ▄▄▄▄▄▄  ▄     ▄  ▄▄▄▄▄▄");
        }
        if (i / 2 + 2 <= 25) {
            gotoxy(1, i / 2 + 2);
            if (i % 2 == 0)
                printf("             ▀     █ █   ▄██ █  █  █ █     █ █     █ █   ▄██ █     █");
            else
                printf("             ▄▀   ▀▄ █    ▄█ █  █  █ █     █ █     █ █    ▄█ █     █");
        }
        if (i / 2 + 3 <= 25) {
            gotoxy(1, i / 2 + 3);
            if (i % 2 == 0)
                printf("                ▄▄▄█ █ ▄█▀ █ ▀▄▄█▄▄▀ █     █ █▄▄▄▄▄▀ █ ▄█▀ █ ▀▄▄▄▄▄█");
            else
                printf("                   █ █  ▄█▀█ █  █  █ █     █ █     █ █  ▄█▀█ █     █");
        }
        if (i / 2 + 4 <= 25) {
            gotoxy(1, i / 2 + 4);
            if (i % 2 == 0)
                printf("             ▄     █ ██▀   █    █    █     █ █       ██▀   █   ▄▀  █");
            else
                printf("                ▀▀▀█ █▄█▀  █  ▀▀█▀▀  █     █ █▀▀▀▀▀  █▄█▀  █  ▀▀█▀▀█");
        }
        if (i / 2 + 5 <= 25) {
            gotoxy(1, i / 2 + 5);
            if (i % 2 == 0)
                printf("              ▀▄▄▄▀  █     █    █    ▀▄▄▄▄▄▀ █       █     █ ▄▀    █");
            else
                printf("             ▀▄   ▄▀ █▀    █    █    █     █ █       █▀    █  ▄▀   █");
        }
        if (i / 2 + 6 <= 25) {
            gotoxy(1, i / 2 + 6);
            if (i % 2 == 0)
                printf("                                                                    ");
            else
                printf("               ▀▀▀   ▀     ▀    ▀     ▀▀▀▀▀  ▀       ▀     ▀ ▀     ▀");
        }
        for (j = i / 2 + 7; j < 26; j++) {
            gotoxy(1, j);
            printf("                                                                     ");
        }
        delay(20);
    }
    strcpy(s, "В Е Р С И Я  1.2");
    gotoxy(33, 20);
    for (i = 0; i < strlen(s); i++) {
        cprintf("%c", s[i]);
        delay(12);
    }
    strcpy(s, "Copyright (c) Ponpa Dmitriy, 41PDM. 1998.");
    gotoxy(21, 22);
    for (i = 0; i < strlen(s); i++) {
        cprintf("%c", s[i]);
        delay(12);
    }
    gotoxy(1, 1);
    getch();
}

/*
        █   █ ▄▀▀▀▄ █▀▀▀▄ ▄▀▀▀▄   ▄▀█ █▀▀▀█ █▀▀▀▄ ▄▀▀▀▄ ▀▀█▀▀ █▀▀▀▄ ▄▀▀▀▄
        █ ▄▀  █   █ █   █ █   █ ▄▀  █ █     █   █ █   ▀   █   █   █ █   █
        █▀▄   █   █ █▄▄▄▀ █   █ █   █ █▀▀   █▀▀▀▄ █       █   █▀▀▀▄ █   █
        █  █  █   █ █     █   █ █   █ █     █   █ █   ▄   █   █   █ █   █
        █   █ ▀▄▄▄▀ █     ▀▄▄▄▀ █   █ █▄▄▄█ █▄▄▄▀ ▀▄▄▄▀   █   █▄▄▄▀ ▀▄▄▄▀

        ▄   ▄  ▄▄▄  ▄▄▄▄   ▄▄▄     ▄▄ ▄▄▄▄▄ ▄▄▄▄   ▄▄▄  ▄▄▄▄▄ ▄▄▄▄   ▄▄▄
        █  ▄▀ █   █ █   █ █   █  ▄▀ █ █   ▀ █   █ █   █   █   █   █ █   █
        █▄▀   █   █ █   █ █   █ █   █ █▄▄   █▄▄▄▀ █       █   █▄▄▄▀ █   █
        █ ▀▄  █   █ █▀▀▀  █   █ █   █ █     █   █ █       █   █   █ █   █
        █  ▀▄ █   █ █     █   █ █   █ █   ▄ █   █ █   █   █   █   █ █   █
        ▀   ▀  ▀▀▀  ▀      ▀▀▀  ▀   ▀ ▀▀▀▀▀ ▀▀▀▀   ▀▀▀    ▀   ▀▀▀▀   ▀▀▀

                        ▄
              ▄▀▀▀▄  █     █ ▄▀▀█▀▀▄ ▄▀▀▀▀▀▄ █▀▀▀▀▀▄ █     █ ▄▀▀▀▀▀█
             ▀     █ █   ▄██ █  █  █ █     █ █     █ █   ▄██ █     █
                ▄▄▄█ █ ▄█▀ █ ▀▄▄█▄▄▀ █     █ █▄▄▄▄▄▀ █ ▄█▀ █ ▀▄▄▄▄▄█
             ▄     █ ██▀   █    █    █     █ █       ██▀   █   ▄▀  █
              ▀▄▄▄▀  █     █    █    ▀▄▄▄▄▄▀ █       █     █ ▄▀    █

               ▄▄▄   ▄  ▀  ▄  ▄▄▄▄▄   ▄▄▄▄▄  ▄▄▄▄▄▄  ▄     ▄  ▄▄▄▄▄▄
             ▄▀   ▀▄ █    ▄█ █  █  █ █     █ █     █ █    ▄█ █     █
                   █ █  ▄█▀█ █  █  █ █     █ █     █ █  ▄█▀█ █     █
                ▀▀▀█ █▄█▀  █  ▀▀█▀▀  █     █ █▀▀▀▀▀  █▄█▀  █  ▀▀█▀▀█
             ▀▄   ▄▀ █▀    █    █    █     █ █       █▀    █  ▄▀   █
               ▀▀▀   ▀     ▀    ▀     ▀▀▀▀▀  ▀       ▀     ▀ ▀     ▀
*/
